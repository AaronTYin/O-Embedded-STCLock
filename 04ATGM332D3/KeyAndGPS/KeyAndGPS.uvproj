# Keil uVision project KeyAndGPS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: KeyAndGPS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Alarm.h AT24C02.h Delay.h Index.h KeyControl.h JudgePassword.h KeyAndGPS.c GPS.h UART.h
