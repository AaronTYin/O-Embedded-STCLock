# Keil uVision project STCLockSCode.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STCLockSCode +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Alarm.h AT24C02.h Delay.h GPS.h GPS_DATA.txt Index.h JudgePassword.h KeyControl.h STCLockSCode.c UART.h Header.h Infrared.h DHT11.h
